# Keil uVision project sys_pia.uvproj, settings and files
target sys_pia (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: sys_pia +hex
  c flags: Optimize=8 SizeSpeed=1
  group sys_pia
    ./: main.c display.c
